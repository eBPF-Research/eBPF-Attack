## defense/lsm-demo/Kconfig
```kconfig
config     SECURITY_DEMO
   bool     "demo support"
   depends on SECURITY
   default     n
   help
        introduction of demo modules
```
